options:
  parameters:
    author: radiogis_director
    generate_options: qt_gui
    id: ook
    output_language: python
    title: ook
  states: {}

blocks:
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Carrier Freq. '
    start: '0'
    step: samp_rate/1000
    stop: samp_rate/8
    value: Rb*4
  states: {}
- name: fd
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Deviation Freq
    start: '0'
    step: samp_rate/1000
    stop: samp_rate/8
    value: Rb
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,2
    label0: Message
    label1: RF Modulated. Time Domain
    label2: RF Modulated. Freq Domain
    label3: Constellation
    num_tabs: '4'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: np.pi/2
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport math\n\nclass blk(gr.sync_block):  \n    \"\"\"\n    Oscilador Controlado por Voltaje (VCO) en RF\n\n    Descripción:\n    Este bloque implementa un oscilador digital que genera una señal cosenoidal\n    de frecuencia fija (fc), cuya amplitud y fase pueden ser controladas en tiempo real\n    mediante dos señales de entrada.\n\n    La señal de salida está dada por:\n    y[n] = A[n] * cos(2*pi*fc*n/samp_rate + Q[n])\n\n    Entradas:\n        1. A[n] (entrada superior):\n           Controla la amplitud instantánea de la señal de salida.\n           Es decir, escala directamente el coseno generado.\n\n        2. Q[n] (segunda entrada):\n           Controla la fase instantánea (en radianes).\n           Permite implementar modulación en fase (PM) o frecuencia (FM si varía en el tiempo).\n\n    Salida:\n        Señal cosenoidal modulada en amplitud y fase.\n\n    Parámetros:\n        fc: frecuencia de la portadora (Hz)\n        samp_rate: frecuencia de muestreo (Hz)\n        \n        \"\"\"\n\n    def __init__(self, fc=128000, samp_rate=320000):  \n        gr.sync_block.__init__(\n            self,\n            name='e_RF_VCO_ff',   \n            in_sig=[np.float32, np.float32],\n            out_sig=[np.float32]\n        )\n        self.fc = fc\n        self.samp_rate = samp_rate\n        self.n_m=0\n\n    def work(self, input_items, output_items):\n        A=input_items[0]\n        Q=input_items[1]\n        y=output_items[0]\n        N=len(A)\n        n=np.linspace(self.n_m,self.n_m+N-1,N)\n        self.n_m += N\n        y[:]=A*np.cos(2*math.pi*self.fc*n/self.samp_rate+Q)\n        return len(output_items[0])\n\n\n"
    fc: fc
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import math

      class blk(gr.sync_block):  
          """Oscilador Controlado por Voltaje en Banda Base (Complex Envelope VCO)

          Descripción:
          Este bloque implementa un VCO en banda base utilizando representación compleja.
          Genera una señal compleja de la forma:

              y[n] = A[n] * exp(j*Q[n])

          donde:
              - A[n] es la amplitud instantánea
              - Q[n] es la fase instantánea (en radianes)

          A diferencia de un VCO en RF (real), este bloque trabaja en envolvente compleja,
          lo cual es típico en sistemas de comunicaciones digitales y SDR.

          Entradas:
              1. A[n] (entrada superior):
                 Controla la magnitud (amplitud) de la señal compleja.
                 Equivale al módulo del número complejo.

              2. Q[n] (segunda entrada):
                 Controla la fase de la señal en radianes.
                 Define el ángulo del fasor complejo.

          Salida:
              Señal compleja (I + jQ) que representa la envolvente en banda base.
              Esta señal puede interpretarse como:
                  - Parte real → componente en fase (I)
                  - Parte imaginaria → componente en cuadratura (Q)

          Parámetros:
              Este bloque no tiene parámetros internos, ya que toda la dinámica
              está definida por las señales de entrada.
              
              """

          def __init__(self,):  
              gr.sync_block.__init__(
                  self,
                  name='e_CE_VCO_fc',   
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.complex64]
              )
              
          def work(self, input_items, output_items):
              A=input_items[0]
              Q=input_items[1]
              y=output_items[0]
              N=len(A)
              y[:]=A*np.exp(1j*Q)
              return len(output_items[0])
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@3:3,1,1,1
    name: '"CE-Constellation"'
    size: '1024'
    type: complex
    width1: '8'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    gui_hint: Menu@2:2,1,1,1
    label1: RF Modulated Signal
    type: float
    width1: '2'
    ymax: '-35'
    ymin: '-65'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    gui_hint: Menu@2:3,1,1,1
    label1: CE-Modulated Signal
    type: complex
    width1: '2'
    ymax: '-35'
    ymin: '-65'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:3,1,1,1
    label1: p2
    marker1: '0'
    name: '"Message bipolar"'
    size: '16'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:4,1,1,1
    label1: p1
    name: Modudating Signal
    size: 16*Sps
    srate: samp_rate
    type: float
    width1: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:2,1,1,1
    label1: Modulating Signal
    label2: RF Modulated signal
    name: Modulating versus RF Modulated Signal
    nconnections: '2'
    size: 16*Sps
    srate: samp_rate
    type: float
    width1: '4'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:3,1,1,1
    label1: I-Signal
    label2: Q-signal
    name: CE Modulated Signal
    size: 16*Sps
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: p2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p3
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p4
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p4b
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: p2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: p3
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: p4
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: p4b
  states: {}

connections:
- [analog_const_source_x_0, '0', epy_block_0, '1']
- [analog_const_source_x_0, '0', epy_block_0_0, '1']
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0_0, '0']
- [epy_block_0, '0', virtual_sink_0_0_0_0, '0']
- [epy_block_0_0, '0', virtual_sink_0_0_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', epy_block_0, '0']
- [interp_fir_filter_xxx_0, '0', epy_block_0_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0_1, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [virtual_source_0_1_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_1_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [virtual_source_0_1_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_1_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_1_0_0, '0', qtgui_time_sink_x_0_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
